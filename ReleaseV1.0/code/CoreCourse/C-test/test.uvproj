# Keil uVision project test.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AT32F407VGT7 ArteryTek
  cpu: IRAM(0x20000000-0x20037FFF) IROM(0x08000000-0x080FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F407VGT7,LIBRARY_VERSION,USE_FULL_ASSERT,AT_START_F407_V1_0
  c include: .\Libraries\AT32F4xx_StdPeriph_Driver;.\Libraries\CMSIS\CM4\CoreSupport;.\Libraries\CMSIS\CM4\DeviceSupport;.\AT32_Board;..\test;.\Libraries\AT32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group BSP
    ./: startup_at32f407vgt7.s system_at32f4xx.c at32f4xx_it.c
    ./AT32_Board/: at32_board.c
  group Drivers
    ./Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_bkp.c at32f4xx_adc.c at32f4xx_can.c at32f4xx_comp.c at32f4xx_crc.c at32f4xx_dac.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_ertc.c at32f4xx_eth.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_xmc.c misc.c
  group APP
    ./: main.c LinkedList.c table.c test.h
