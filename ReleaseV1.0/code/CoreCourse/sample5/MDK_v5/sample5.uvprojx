# Keil uVision project sample5.uvprojx, settings and files
target sample5 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AT32F407VGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.1
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: W25Q_Flash +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F407VGT7,LIBRARY_VERSION,AT_START_F407_V1_0
  c include: ..\Libraries\CMSIS\CM4\CoreSupport;..\Libraries\CMSIS\CM4\DeviceSupport;..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\EN25Q;..\AT32_Board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group APP
    ../: main.c
  group BSP
    ../: at32f4xx_it.c
    ../AT32_Board/: at32_board.c
  group Startup
    ../: system_at32f4xx.c startup_at32f407vgt7.s
  group Drivers
    ../EN25Q/: spi_flash.c
    ../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_gpio.c at32f4xx_spi.c at32f4xx_usart.c misc.c at32f4xx_rcc.c
