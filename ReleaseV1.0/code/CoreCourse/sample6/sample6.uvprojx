# Keil uVision project sample6.uvprojx, settings and files
target sample6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AT32F407VGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.1
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sample6 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F407VGT7,LIBRARY_VERSION,AT_START_F407_V1_0
  c include: .\Libraries\AT32F4xx_StdPeriph_Driver\inc;.\Libraries\USB-FS-Device_Driver\inc;.\AT32_Board\inc;.\Libraries\CMSIS\CM4\CoreSupport;.\Libraries\CMSIS\CM4\DeviceSupport
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group HID_App
    ./USB_App/: main.c
  group Startup
    ./Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f407vgt7.s
  group BSP
    ./AT32_Board/src/: at32_board.c at32f4xx_it.c hw_config.c system_at32f4xx.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USB_Device_Drivers
    ./Libraries/USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Standard_Drivers
    ./Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_crc.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_rcc.c at32f4xx_spi.c at32f4xx_usart.c at32f4xx_acc.c misc.c
