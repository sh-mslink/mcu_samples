# Keil uVision project ble.uvprojx, settings and files
target BLE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AT32F407VGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x38000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BLE
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F407VGT7,USE_STDPERIPH_DRIVER,AT_START_F407_V1_0,LIBRARY_VERSION,USE_UART
  c include: ..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\BLE;..\..\..\..\AT32_Board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../: main.c app.c BSP.c HDC2080.c at32f4xx_it.c mg_BLEpair_lib_m3.lib retarget.c
  group BSP
    ../../../../AT32_Board/: at32_board.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f407vgt7.s
  group AT32Periph
    ../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_gpio.c at32f4xx_exti.c at32f4xx_iwdg.c at32f4xx_rcc.c at32f4xx_spi.c at32f4xx_usart.c at32f4xx_tim.c misc.c
