# IAR project Backup of Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F407VGT7 ArteryTek AT32F407VGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F407VGT7; LIBRARY_VERSION; AT_START_F407_V1_0
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\CM4\CoreSupport; ..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport; ..; ..\..\..\AT32_Board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.hex
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group AT32Periph
    ../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_crc.c at32f4xx_dac.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_xmc.c misc.c
  group BSP
    ../../../AT32_Board/: at32_board.c
  group CMSIS
    ../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/iar/: startup_at32f407vgt7.s
    ../: system_at32f4xx.c
  group README
    ../: readme.txt
  group USER
    ../: at32f4xx_it.c main.c
