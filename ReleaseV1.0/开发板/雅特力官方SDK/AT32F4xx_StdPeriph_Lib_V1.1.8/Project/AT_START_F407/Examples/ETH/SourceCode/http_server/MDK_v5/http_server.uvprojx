# Keil uVision project http_server.uvprojx, settings and files
target http_server (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AT32F407VGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.1
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tcp_client
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F407VGT7,LIBRARY_VERSION,AT_START_F407_V1_0
  c include: ..\..\..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\..\..\..\..\AT32_Board;..\Utilities\lwip-1.3.1\port;..\Utilities\lwip-1.3.1\src\include;..\Utilities\lwip-1.3.1\src\include\ipv4;..\Utilities\lwip-1.3.1\src\include\lwip;..\..\http_server
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../: main.c netconf.c at32f4xx_it.c eth_config.c httpd.c
  group BSP
    ../../../../../../AT32_Board/: at32_board.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f407vgt7.s
  group AT32Periph
    ../../../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_adc.c at32f4xx_dma.c at32f4xx_eth.c at32f4xx_gpio.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_usart.c misc.c
  group LwIP
    ../Utilities/lwip-1.3.1/port/: ethernetif.c
    ../Utilities/lwip-1.3.1/src/api/: tcpip.c api_lib.c netbuf.c netifapi.c netdb.c api_msg.c err.c
    ../Utilities/lwip-1.3.1/src/core/: stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c dhcp.c init.c mem.c memp.c netif.c pbuf.c raw.c
    ../Utilities/lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../Utilities/lwip-1.3.1/src/netif/: etharp.c
  group README
    ../: readme.txt
